# Keil uVision project LED.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: LED
  c flags: Optimize=8 SizeSpeed=1
  group New Group
    ./: LED.c
